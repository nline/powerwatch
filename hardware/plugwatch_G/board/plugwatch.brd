File: hardware/plugwatch_G/board/plugwatch.brd (EAGLE design)
At the start: 55.7 x 95.2 mm, 126 parts, among them J1 DM3AT-SF-PEJM5, J2 SCREW_TERMNIAL_1, J3 SCREW_TERMNIAL_1, U1 AB1815-T3, U10 OPA369, U11 SIP32510, U12 SIP32510, U13 SIP32510, U14 SIP32510, U2 BGA725L6-ALT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

Commit message: update board and schematic with changes from last revision
Parts:
- removed ASSY2: WRL-13678, chips:WRL-13678
- removed C11: 1uF, passives:0402_CAP
- removed D5: BLUE, leds:LED-0603
- removed R23: 100k, passives:0402_RES
- removed R4: 68, passives:0402_RES
- removed R5: 1k, passives:0402_RES
- removed TP1, TP2, TP20, TP21, TP22, TP3: TEST_POINT_0.040IN, headers:TESTPOINT_0.040IN
- removed U13: SIP32510, chips:TSOT23-6
- removed U15: (no value), microphones:SPH0465
- added Q1: NX3008PBK, fets:SOT23-3
- added Q2: MOSFET-NCHANNELSMD, fets:SOT23-3
- R1: value 66.5 -> 66.5K
- R2: value 68 -> 100k
- R27: value 499k -> 1M
- R3: value 68 -> 1M
- moved R3 87.9 mm to (2.67, -16.0)
- moved R2 82.8 mm to (2.67, -7.37)
Connections:
- removed net MIC_BCLK: ASSY1.D4, R3.2, TP22.TESTPOINT
- removed net MIC_DATA: ASSY1.D2, R4.1, TP21.TESTPOINT
- removed net MIC_WS: ASSY1.D5, R2.2, TP20.TESTPOINT
- removed net N$1: D5.A, R5.1
- removed net N$12: R3.1, U15.4
- removed net N$14: ASSY2.4, ASSY2.6, ASSY2.8, U13.1, U13.2
- removed net N$15: R4.2, U15.6
- removed net N$2: D5.C, U7.4
- removed net N$3: R2.1, U15.1
- removed net WIFI_PWR_EN: ASSY1.B1, R23.2, TP1.TESTPOINT, U13.3
- removed net WIFI_RXD: ASSY1.C1, ASSY2.7, TP3.TESTPOINT
- removed net WIFI_TXD: ASSY1.C0, ASSY2.2, TP2.TESTPOINT
- new net !RTC_INT2: ASSY1.D2, Q1.1, R2.2, U1.4
- new net DO_NOT_CONNECT: ASSY1.D7
- new net GPS_PPS: ASSY1.D4, U7.4
- new net PARTICLE_RST: Q2.1, R3.1
- net !RTC_INT1: now also ASSY1.D5; no longer ASSY1.D7
- net GND: now also Q2.2, R3.2; no longer ASSY2.1, C11.2, R23.1, U13.4, U15.3
- net GPS_VCC: no longer R5.2
- net N$10: now also Q1.3
- net N$31: now also Q2.3
- net VCC: now also Q1.2, R2.1; no longer C11.1, U13.5, U13.6, U15.2, U15.5
Routing:
- net WIFI_TXD: track 87.6 -> 0.00 mm
- net WIFI_PWR_EN: track 87.3 -> 0.00 mm
- net WIFI_RXD: track 73.4 -> 0.00 mm
- net MIC_BCLK: track 40.6 -> 0.00 mm, vias 3 -> 0
- net MIC_WS: track 37.4 -> 0.00 mm, vias 1 -> 0
- net MIC_DATA: track 33.9 -> 0.00 mm, vias 2 -> 0
- net N$14: track 8.55 -> 0.00 mm
- net VCC: track 191.9 -> 186.3 mm
- net N$2: track 2.00 -> 0.00 mm
- net GPS_VCC: track 2.18 -> 0.25 mm
- net N$12: track 1.28 -> 0.00 mm
- net N$3: track 1.26 -> 0.00 mm
- net N$15: track 1.25 -> 0.00 mm
- net N$1: track 1.16 -> 0.00 mm
- net !RTC_INT1: track 68.0 -> 67.5 mm
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Other:
- board text added: "PowerWatch Josh Adkins Noah Klugman Rev G, 5/19"
- board text removed: "BCLK"
- board text removed: "DATA"
- board text removed: "PowerWatch Noah Klugman Josh Adkins Rev F, 11/18"
- board text removed: "WS"
- board text removed: "WiEN"
- board text removed: "WiTX"

Commit message: add new voltage amplifier circuit
Parts:
- removed D1, D2, D3, D4: (no value), passives:SOD323
- removed R37, R38, R39, R40: 1M, passives:0402_RES
- removed U10, U9: OPA369, powerfilm:SC70-5
- added C11, C18: 0.1uF, passives:0402_CAP
- added R23: 953k, passives:0402_RES
- added R4: 1, resistor:R2512
- added R5: 3.74k, passives:0402_RES
- added U13: ADA4096-4ACPZ-R7, ada4096-4:CP_16_27
- added U15: REF2033AIDDCR, ref2033:DDC5
- R28, R30, R31: value 750k -> 953k; device passives:1206_RES_HIGH_CLEARANCE -> passives:0402_RES
- R29: value 750k -> 3.75k; device passives:1206_RES_HIGH_CLEARANCE -> passives:0402_RES
- R33: value 953k -> 1.00k
- R35: device passives:1206_RES_HIGH_CLEARANCE -> passives:0402_RES
- R36: value 953k -> 1.00k; device passives:1206_RES_HIGH_CLEARANCE -> passives:0402_RES
- R6, R7: value 4.99k -> 953k
- moved R35 116.5 mm to (2.79, -86.7), turned to 0 degrees
- moved R33 108.7 mm to (2.79, -76.2), turned to 0 degrees
- moved R36 106.0 mm to (2.79, -90.6), turned to 0 degrees
- moved R34 97.5 mm to (2.79, -82.9)
- moved R30 96.0 mm to (2.79, -68.6), turned to 0 degrees
- moved R31 90.1 mm to (2.79, -72.4), turned to 0 degrees
- moved R28 83.2 mm to (2.79, -58.0), turned to 0 degrees
- moved C5 82.1 mm to (2.41, -51.3), turned to 0 degrees
- moved R29 81.9 mm to (2.79, -61.8), turned to 0 degrees
- moved R6 76.2 mm to (2.79, -43.7), turned to 0 degrees
- moved C6 74.9 mm to (2.41, -65.7), turned to 0 degrees
- moved R7 61.1 mm to (2.79, -47.5), turned to 0 degrees
Connections:
- removed net AC/L-FUSED: F1.P$2, R28.1, R30.1, R35.1, U5.AC/L, V1.1
- removed net AC/N-FUSED: J3.P$1, J3.P$2, R29.1, R31.1, R36.1, U5.AC/N, V1.2
- removed net N$38: F1.P$1, J2.P$1, J2.P$2
- removed net N$42: R37.1, R38.2, U9.P1
- removed net N$43: R33.2, R35.2, R6.1, U9.P3
- removed net N$44: R39.1, R40.2, U10.P1
- removed net N$45: R34.2, R36.2, R7.1, U10.P3
- removed net SENSE_VCC: C5.1, C6.1, R37.2, R39.2, U10.P5, U14.1, U14.2, U9.P5
- new net AC_L_HV_OUT: R33.2, U13.7
- new net AC_L_LV_OUT: R5.2, U13.15
- new net AC_L_SENSE: F1.P$1, J2.P$1, J2.P$2, R31.2, R6.1
- new net AC_N: J3.P$1, J3.P$2, R23.1, R34.2, U5.AC/N, V1.2
- new net AC_N_HV_OUT: R36.2, U13.14
- new net AC_N_LV_OUT: R29.1, U13.6
- new net AC_SENSE_VCC: U14.1, U14.2, U15.3, U15.4
- new net N$1: F1.P$2, R4.1
- new net N$2: R4.2, U5.AC/L, V1.1
- new net N$3: R23.2, R28.2, R29.2, U13.5
- new net N$4: R5.1, R6.2, R7.2, U13.1
- new net N$6: R30.1, R31.1, R33.1, U13.8
- new net N$8: R34.1, R35.1, R36.1, U13.12
- new net REF_1V65: C11.1, C18.1, C5.1, C6.1, U13.11, U13.2, U13.4, U13.9, U15.1
- new net REF_3V3: U13.3, U15.5
- net AC/L-MEASURE: no longer D1.P$1, R30.2
- net AC/L-PERTURB: no longer D2.P$1, R28.2
- net AC/L-SENSE: no longer R6.2, U9.P4
- net AC/N-MEASURE: no longer D3.P$1, R31.2
- net AC/N-PERTURB: no longer D4.P$1, R29.2
- net AC/N-SENSE: no longer R7.2, U10.P4
- net GND: now also C11.2, C18.2, R28.1, R30.2, R35.2, R7.1, U13.10, U13.17, U15.2; no longer D1.P$2, D2.P$2, D3.P$2, D4.P$2, R33.1, R34.1, R38.1, R40.1, U10.P2, U9.P2
Routing:
- net AC/N-FUSED: track 54.2 -> 0.00 mm, vias 1 -> 0
- net AC/L-FUSED: track 51.3 -> 0.00 mm, vias 1 -> 0
- net SENSE_VCC: track 36.3 -> 0.00 mm, vias 4 -> 0
- net AC_N: track 0.00 -> 30.8 mm, vias 0 -> 1
- net N$38: track 9.19 -> 0.00 mm
- net AC_L_SENSE: track 0.00 -> 9.19 mm
- net N$45: track 6.39 -> 0.00 mm
- net N$43: track 5.51 -> 0.00 mm
- net N$42: track 3.99 -> 0.00 mm
- net AC/L-PERTURB: track 87.8 -> 84.5 mm
- net AC/N-PERTURB: track 100.3 -> 97.1 mm
- net AC/L-MEASURE: track 83.3 -> 80.3 mm
- net AC/N-MEASURE: track 87.5 -> 85.2 mm
- net N$44: track 2.01 -> 0.00 mm
- net AC/L-SENSE: track 79.6 -> 77.7 mm
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
Commit message: finish up direct voltage sensing, add coprocessor and i2c translator
Parts:
- added C19, C21: 0.1uF, passives:0402_CAP
- added C20, C22: 1uF, passives:0402_CAP
- added C23: 4.7uF, passives:0402_CAP
- added C24, C25: 4.3pF, passives:0402_CAP
- added J4: TC2030-JLINK-L, connector:TC2030-IDC
- added R37: 10k, passives:0402_RES
- added S1: B3U-1000P, switches:B3U-1000P
- added U10: STM32L432KC, chips:UQFN-32
- added U16: TCA9406DCUR, tca9406:DCU8
- added U9: TPS79330DBVR, tps7933:DBV5
- added X2: ABS05-32.768KHZ-T, crystals:ABS05
- U15: value REF2033AIDDCR -> REF2030AIDDCR
Connections:
- net REF_1V65 renamed REF_1V5
- removed net REF_3V3: U13.3, U15.5
- new net !RST: J4.3, R37.2, S1.2, U10.31, U10.4
- new net AC_COPROC_VCC: C21.1, C22.1, C23.1, J4.1, U10.1, U10.17, U16.3, U16.6, U9.5
- new net AC_SCL: U10.19, U16.5
- new net AC_SDA: U10.20, U16.4
- new net N$11: C24.2, U10.2, X2.B
- new net N$9: C25.2, U10.3, X2.A
- new net REF_3V: C19.1, C20.1, U10.5, U13.3, U15.5
- new net SWDCLK: J4.4, U10.24
- new net SWDIO: J4.2, U10.23
- net AC_L_HV_OUT: now also U10.8
- net AC_L_LV_OUT: now also U10.6
- net AC_N_HV_OUT: now also U10.9
- net AC_N_LV_OUT: now also U10.7
- net AC_SENSE_VCC: now also U9.1, U9.3
- net GND: now also C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.1, J4.5, R37.1, S1.1, U10.16, U10.32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
- net SENSORS_SCL: now also U16.8
- net SENSORS_SDA: now also U16.1
- net VCC: now also U16.7

Commit message: add TDR, connect PPS, add transient spike detectors
Parts:
- added C26, C27, C28, C29: 0.01uF, passives:0402_CAP
- added C30, C33: 100pF, passives:0402_CAP
- added C31, C32, C34, C35: 10nF, passives:0402_CAP
- added D1, D2, D21, D22, D23, D26: 2000Vr, diode:DO214AC
- added D10, D11, D19, D20, D25, D28: 3V, SparkFun-DiscreteSemi:SOD-323
- added D12, D13, D14, D15, D16, D17, D18, D3, D4, D5, D6, D7, D8, D9: 200V, diode:DO214AA
- added D24, D27: >1kVr, diode:DO214AC
- added R38, R39, R40, R42: 10, passives:0402_RES
- added R43, R46: 40, passives:0402_RES
- added R44, R47: 800k, passives:0402_RES
- added R45, R48: 1M, passives:0402_RES
- added U17, U18, U21, U22: SN74LVC1G86DBVR, SN74LVC:DBV5
- moved R4 230.1 mm to (-2.80, -251.7)
Connections:
- new net !RST1: R43.2, U21.4, U22.2
- new net !RST2: R46.2, U17.4, U18.2
- new net AC_L_600V_DETECT: C27.1, D11.C, D4.A, U10.28
- new net AC_L_800V_DETECT: C26.1, D10.C, D6.A, U10.27
- new net AC_N1: D23.A, U22.4
- new net AC_N2: D26.A, U18.4
- new net AC_N_600V_DETECT: C29.1, D13.A, D20.C, U10.30
- new net AC_N_800V_DETECT: C28.1, D15.A, D19.C, U10.29
- new net GND1: C30.1, R43.1, U22.1
- new net GND2: C33.1, R46.1, U18.1
- new net N$12: F1.P$1, J2.P$1, J2.P$2
- new net N$14: D8.C, D9.A
- new net N$15: D7.C, D8.A
- new net N$16: D6.C, D7.A
- new net N$17: C34.1, D27.C, R47.2
- new net N$22: D5.C, R39.1
- new net N$24: D3.A, D4.C
- new net N$30: D9.C, R38.1
- new net N$32: D1.C, R38.2
- new net N$33: D2.C, R39.2
- new net N$34: D12.C, D14.A
- new net N$35: D17.C, D18.A
- new net N$37: D16.C, D17.A
- new net N$38: D15.C, D16.A
- new net N$43: D12.A, D13.C
- new net N$44: C31.1, D24.C, R44.2
- new net N$45: D14.C, R42.1
- new net N$46: D18.C, R40.1
- new net N$47: D21.C, R40.2
- new net N$48: D22.C, R42.2
- new net TDR_L_DETECT: C32.1, D25.C, R44.1, R45.2, U10.10
- new net TDR_L_TRIGGER: U10.12, U21.2
- new net TDR_N_DETECT: C35.1, D28.C, R47.1, R48.2, U10.11
- new net TDR_N_TRIGGER: U10.13, U17.2
- net AC_L_SENSE: now also D1.A, D2.A, D23.C, D24.A, F1.P$2, R4.1; no longer F1.P$1, J2.P$1, J2.P$2
- net AC_N: now also D21.A, D22.A, D26.C, D27.A
- net AC_SENSE_VCC: now also U17.5, U18.5, U21.5, U22.5
- net GND: now also C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, D10.A, D11.A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
- net GPS_PPS: now also U10.26
- net N$1: now also D3.C, D5.A; no longer F1.P$2, R4.1
Routing:
- net AC_L_SENSE: track 9.19 -> 0.00 mm

Commit message: split the symbol up for the op amp so it's readable
Parts:
- R29: value 3.75k -> 3.74k
- moved U13 309.9 mm to (-22.9, -336.4)
Connections:
- net AC_L_HV_OUT: now also U13.14; no longer U13.7
- net AC_L_LV_OUT: now also U13.7; no longer U13.15
- net AC_N_HV_OUT: now also U13.6; no longer U13.14
- net AC_N_LV_OUT: now also U13.15; no longer U13.6
- net N$3: now also U13.1; no longer U13.5
- net N$4: now also U13.8; no longer U13.1
- net N$6: now also U13.12; no longer U13.8
- net N$8: now also U13.5; no longer U13.12

File: hardware/plugwatch_G/board/plugwatch.sch (EAGLE design)
At the start: 155 parts, among them J1 DM3AT-SF-PEJM5, J4 TC2030-JLINK-L, Q1 NX3008PBK, Q2 MOSFET-NCHANNELSMD, U1 AB1815-T3, U10 STM32L432KC, U11 SIP32510, U12 SIP32510, U13 ADA4096-4ACPZ-R7, U14 SIP32510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

Commit message: finish routing board
Parts:
- removed C27, C29: 0.01uF, passives:CAPACITOR0402_CAP
- removed D11, D20: 3V, SparkFun-DiscreteSemi:DIODE-ZENER-MM3Z3V3T1G
- removed D12, D13, D14, D3, D4, D5: 200V, diode:DIODE-DO214AA
- removed D2, D22: 2000Vr, diode:DIODE-DO214AC
- removed R39, R42: 10, passives:RESISTOR0402_RES
Connections:
- net GND1 renamed A
- net GND2 renamed A2
- removed net AC_L_600V_DETECT: C27.1, D11.C, D4.A, U10.PB5
- removed net AC_N_600V_DETECT: C29.1, D13.A, D20.C, U10.PB7
- removed net N$1: D3.C, D5.A
- removed net N$22: D5.C, R39.1
- removed net N$24: D3.A, D4.C
- removed net N$33: D2.C, R39.2
- removed net N$34: D12.C, D14.A
- removed net N$43: D12.A, D13.C
- removed net N$45: D14.C, R42.1
- removed net N$48: D22.C, R42.2
- net AC_L_800V_DETECT: now also ASSY1.B1; no longer ASSY1.B5
- net AC_L_HV_OUT: now also U10.PA0/CLKIN; no longer U10.PA2
- net AC_L_LV_OUT: now also U10.PA3; no longer U10.PA0/CLKIN
- net AC_L_SENSE: no longer D2.A
- net AC_N: no longer D22.A
- net AC_N_800V_DETECT: now also ASSY1.C1; no longer ASSY1.B4
- net AC_N_HV_OUT: now also U10.PA2; no longer U10.PA3
- net GND: no longer C27.2, C29.2, D11.A, D20.A
- net TDR_L_DETECT: now also ASSY1.B2, U10.PA7; no longer ASSY1.B3, U10.PA4
- net TDR_L_TRIGGER: now also ASSY1.B3; no longer ASSY1.B1
- net TDR_N_DETECT: now also ASSY1.B4; no longer ASSY1.B2
- net TDR_N_TRIGGER: now also ASSY1.B5, U10.PA4; no longer ASSY1.C1, U10.PA7
Other:
- moved on the sheet: C26, D1, D10, D6, D7, D8, D9, R38

Commit message: renumber components, add cutout
Parts:
- removed C36: 0.1uF, passives:CAPACITOR0402_CAP
- removed R48: 750, passives:RESISTOR0402_RES
- removed R49: 474, passives:RESISTOR0402_RES
- removed U22: SN74LVC1G86DRLRDRL5-L, SN74LVC1G86:SN74LVC1G86DRLRDRL5-L
- added C29: 4.7uF, passives:CAPACITOR0402_CAP
- added R39, R42: 953k, passives:RESISTOR0402_RES
- added U20: TCA9406DCUR, tca9406:TCA9406DCUR
- C1: value 47pF -> 4.3pF; DESCRIPTION CAP CER 47PF 100V C0G/NP0 0402 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 490-7307-1-ND -> 311-1336-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GRM1555C2A470JA01D -> CC0402KRX5R6BB104
- C10: value 1uF -> 10nF; DESCRIPTION CAP CER 1UF 10V X7S 0402 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 490-13409-1-ND -> 311-1336-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GCM155C71A105KE38D -> CC0402KRX5R6BB104
- C11: value 0.1uF -> 10nF
- C12: value 4.7uF -> 10nF; DESCRIPTION CAP CER 4.7UF 6.3V X5R 0402 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 445-5947-1-ND -> 311-1336-1-ND; MANUFACTURER TDK -> Yageo; MPN C1005X5R0J475K050BC -> CC0402KRX5R6BB104
- C13: value 10uF -> 10nF; DESCRIPTION CAP CER 10UF 6.3V X5R 0402 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 490-13211-1-ND -> 311-1336-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GRJ155R60J106ME11D -> CC0402KRX5R6BB104
- C14: value 10uF -> 0.1uF; DESCRIPTION CAP CER 10UF 6.3V X5R 0402 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 490-13211-1-ND -> 311-1336-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GRJ155R60J106ME11D -> CC0402KRX5R6BB104
- C15, C16: value 100uF -> 0.1uF; device passives:CAPACITOR1210_CAP -> passives:CAPACITOR0402_CAP; DESCRIPTION CAP CER 100UF 6.3V X7S 1210 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 490-10530-1-ND -> 311-1336-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GRM32EC70J107ME15L -> CC0402KRX5R6BB104
- C17: value 2000uF -> 0.1uF; device rcl:CPOL-USE5-13 -> passives:CAPACITOR0402_CAP; DESCRIPTION CAP ALUM 2000UF 20% 6.3V T/H -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY P122284TB-ND -> 311-1336-1-ND; MANUFACTURER Panasonic Electronic Components -> Yageo; MPN EEU-FS0J202B -> CC0402KRX5R6BB104
- C2: value 10nF -> 4.3pF; DESCRIPTION CAP CER 10000PF 16V X7R 0402 -> CAP CER 0.1UF 10V X5R 0402; DIGIKEY 490-1313-1-ND -> 311-1336-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GRM155R71C103KA01D -> CC0402KRX5R6BB104
- C20, C22: value 1uF -> 0.1uF
- C23: value 4.7uF -> 0.82uF; DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> (none); DIGIKEY 311-1336-1-ND -> 490-10440-1-ND; MANUFACTURER Yageo -> Murata Electronics North America; MPN CC0402KRX5R6BB104 -> GRM155C80J824KE15D
- C24: value 4.3pF -> 1uF; DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 1UF 10V X7S 0402; DIGIKEY 311-1336-1-ND -> 490-13409-1-ND; MANUFACTURER Yageo -> Murata Electronics North America; MPN CC0402KRX5R6BB104 -> GCM155C71A105KE38D
- C25: value 4.3pF -> 1uF
- C26: value 0.01uF -> 1uF
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Connections:
- net !EXTERNAL_RST: now also R22.2, U9.!RESET; no longer R17.2, U8.!RESET
- net !RST: now also U19.!RST; no longer U10.!RST
- net !RST1: now also R4.2, U15.Y, U16.B; no longer R43.2, U21.Y, U22.B
- net !RST2: now also R5.2; no longer R46.2
- net !RTC_CS: now also R21.2, R23.2; no longer R16.2, R18.2
- net !RTC_INT1: now also R20.2; no longer R15.2
- net !RTC_INT2: now also Q2.G, R33.2; no longer Q1.G, R2.2
- net !SD_CS: now also R16.1; no longer R11.1
- net !SD_DETECT: now also R27.1; no longer R20.1
- net 5V: now also C33.1, C34.1, C35.+, R25.1, R30.1, R46.1, U6.V+; no longer C15.1, C16.1, C17.+, R19.1, R24.1, R41.1, U5.V+
- net A: now also C4.1, R4.1, U16.A; no longer C30.1, R43.1, U22.A
- net A2: now also C5.1, R5.1; no longer C33.1, R46.1
- net ACCEL_INT: now also U7.INT1; no longer U6.INT1
- net AC_COPROC_VCC: now also C26.1, C30.1, U19.VDD, U20.OE, U20.VCCA, U21.OUT; no longer C23.1, C36.1, U10.VDD, U16.OE, U16.VCCA, U9.OUT
- net AC_L_800V_DETECT: now also C10.1, U19.PB4/!JTRST; no longer C26.1, U10.PB4/!JTRST
- net AC_L_HV_OUT: now also R8.2, U19.PA0/CLKIN, U2D.OUT; no longer R33.2, U10.PA0/CLKIN, U13D.OUT
- net AC_L_LV_OUT: now also R11.2, U19.PA3, U2C.OUT; no longer R5.2, U10.PA3, U13C.OUT
- net AC_L_SENSE: now also R1.1, R37.1, R42.2; no longer R31.2, R4.1, R6.1
- net AC_N: now also R39.1, R43.2, U6.AC/N; no longer R23.1, R34.2, U5.AC/N
- net AC_N1: now also U16.Y; no longer U22.Y
- net AC_N_800V_DETECT: now also C11.1, U19.PB6; no longer C28.1, U10.PB6
- net AC_N_HV_OUT: now also R9.2, U19.PA2, U2B.OUT; no longer R36.2, U10.PA2, U13B.OUT
- net AC_N_LV_OUT: now also R12.1, U19.PA1, U2A.OUT; no longer R29.1, U10.PA1, U13A.OUT
- net AC_SCL: now also U19.PA9, U20.SCL_A; no longer U10.PA9, U16.SCL_A
- net AC_SDA: now also U19.PA10, U20.SDA_A; no longer U10.PA10, U16.SDA_A
- net AC_SENSE_PWR_EN: now also R32.2; no longer R26.2
- net AC_SENSE_VCC: now also U11.EN, U11.VIN, U15.VCC, U16.VCC, U21.EN, U21.IN; no longer U15.EN, U15.VIN, U21.VCC, U22.VCC, U9.EN, U9.IN
- net BOOT0: now also R24.2, U19.PH3/BOOT0; no longer R37.2, U10.PH3/BOOT0
- net GND: now also C1.1, C17.2, C24.2, C25.2, C29.2, C3.2, C32.1, C35.-, C7.2, C8.1, C9.1, Q1.S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; no longer C1.2, C17.-, C24.1, C25.1, C3.1, C32.2, C35.2, C36.2, C7.1, C8.2, C9.2, Q2.S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
- net GPS_PPS: now also U19.PB3/JTDO/SWO, U8.TIMEPULSE; no longer U10.PB3/JTDO/SWO, U7.TIMEPULSE
- net GPS_PWR_EN: now also R29.2, U12.EN; no longer R22.2, U11.EN
- net GPS_RF_IN: now also U5.OUTPUT, U8.RF_IN; no longer U4.OUTPUT, U7.RF_IN
- net GPS_VCC: now also C32.2, C9.2, U12.VLOAD, U8.VCC, U8.VCC_IO, U8.V_BCKP; no longer C3.2, C7.2, U11.VLOAD, U7.VCC, U7.VCC_IO, U7.V_BCKP
- net LNA_IN: now also U3.AI; no longer U2.AI
- net LNA_OUT: now also U3.AO, U5.INPUT; no longer U2.AO, U4.INPUT
- net N$10: now also Q2.D, R25.2, R26.1; no longer Q1.D, R1.1, R19.2
- net N$11: now also C1.2, U19.PC14/OSC32IN, X1.2; no longer C24.2, U10.PC14/OSC32IN, X2.2
- net N$13: now also C3.1; no longer C1.1
- net N$17: now also C13.1, R35.2; no longer C34.1, R47.2
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
Commit message: add board and schematic with final part numbers
Parts:
- removed D21, D23, D26: 2000Vr, diode:DIODE-DO214AC
- removed D24, D27: >1kVr, diode:DIODE-DO214AC
- added D11, D12, D13: 200V, diode:DIODE-DO214AA
- added D14: 1000Vr, diode:DIODE-DO214AC
- added D2: 3V, SparkFun-DiscreteSemi:DIODE-ZENER-MM3Z3V3T1G
- added D5: LED0603, leds:LED0603
- added R48: 1M, passives:RESISTOR0402_RES
- C1, C2: DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 4.3PF 50V C0G/NP0 0402; DIGIKEY 311-1336-1-ND -> 490-3099-1-ND; MANUFACTURER Yageo -> Murata Electronics North America; MPN CC0402KRX5R6BB104 -> GJM1555C1H4R3CB01D
- C10, C11: DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 10000PF 16V X7R 0402; DIGIKEY 311-1336-1-ND -> 490-1313-1-ND; MANUFACTURER Yageo -> Murata Electronics North America; MPN CC0402KRX5R6BB104 -> GRM155R71C103KA01D
- C12, C13: device passives:CAPACITOR0402_CAP -> SparkFun-Capacitors:CAP1206; DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 10000PF 630V X7R 1206; DIGIKEY 311-1336-1-ND -> 445-2291-1-ND; MANUFACTURER Yageo -> TDK Corporation; MPN CC0402KRX5R6BB104 -> C3216X7R2J103K115AA
- C23: DESCRIPTION (none) -> CAP CER 0.82UF 10V X5R 0402; DIGIKEY 490-10440-1-ND -> 311-3789-1-ND; MANUFACTURER Murata Electronics North America -> Yageo; MPN GRM155C80J824KE15D -> CC0402KRX5R6BB824
- C25, C26, C27: DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 1UF 10V X7S 0402; DIGIKEY 311-1336-1-ND -> 490-13409-1-ND; MANUFACTURER Yageo -> Murata Electronics North America; MPN CC0402KRX5R6BB104 -> GCM155C71A105KE38D
- C29: DESCRIPTION CAP CER 4.7UF 6.3V X5R 0402 -> CAP CER 4.7UF 6.3V X5R 0402; DIGIKEY 445-5947-1-ND -> 445-5947-1-ND; MANUFACTURER TDK -> TDK Corporation; MPN C1005X5R0J475K050BC -> C1005X5R0J475K050BC
- C30: DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 4.7UF 6.3V X5R 0402; DIGIKEY 311-1336-1-ND -> 445-5947-1-ND; MANUFACTURER Yageo -> TDK Corporation; MPN CC0402KRX5R6BB104 -> C1005X5R0J475K050BC
- C4, C5: DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 100PF 50V C0G/NPO 0402; DIGIKEY 311-1336-1-ND -> 311-1024-1-ND; MPN CC0402KRX5R6BB104 -> CC0402JRNPO9BN101
- C6, C7: DESCRIPTION CAP CER 0.1UF 10V X5R 0402 -> CAP CER 1000PF 50V X7R 0402; DIGIKEY 311-1336-1-ND -> 490-6350-1-ND; MANUFACTURER Yageo -> Murata Electronics North America; MPN CC0402KRX5R6BB104 -> GRM155R71H102KA01J
- D1: value 2000Vr -> 3V; device diode:DIODE-DO214AC -> SparkFun-DiscreteSemi:DIODE-ZENER-MM3Z3V3T1G; DESCRIPTION (none) -> DIODE ZENER 3V 300MW SOD323; DIGIKEY (none) -> MM3Z3V0ST1GOSCT-ND; MANUFACTURER (none) -> ON Semiconductor; MPN (none) -> MM3Z3V0ST1G
- D10: value 3V -> 200V; device SparkFun-DiscreteSemi:DIODE-ZENER-MM3Z3V3T1G -> diode:DIODE-DO214AA; DESCRIPTION (none) -> DIODE ZENER 200V 3W DO214AA; DIGIKEY (none) -> 1PGSMB5956R5GCT-ND; MANUFACTURER (none) -> Taiwan Semiconductor Corporation; MPN (none) -> 1PGSMB5956 R5G
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Connections:
- new net N$1: D5.CATHODE, R11.2
- new net N$7: D5.ANODE, U19.PB1
- net !EXTERNAL_RST: now also R23.2; no longer R22.2
- net !RTC_CS: now also R22.2, R24.2; no longer R21.2, R23.2
- net !RTC_INT1: now also R21.2; no longer R20.2
- net !RTC_INT2: now also R34.2; no longer R33.2
- net !SD_CS: now also R17.1; no longer R16.1
- net !SD_DETECT: now also R28.1; no longer R27.1
- net 5V: now also R26.1, R31.1, R47.1; no longer R25.1, R30.1, R46.1
- net AC_L_800V_DETECT: now also D1.C; no longer D10.C
- net AC_L_LV_OUT: now also R12.2; no longer R11.2
- net AC_L_SENSE: now also D14.A, D16.C, D17.A, R38.1, R43.2; no longer D1.A, D23.C, D24.A, R37.1, R42.2
- net AC_N: now also D15.A, D18.C, D19.A, R40.1, R44.2; no longer D21.A, D26.C, D27.A, R39.1, R43.2
- net AC_N1: now also D16.A; no longer D23.A
- net AC_N2: now also D18.A; no longer D26.A
- net AC_N_800V_DETECT: now also D10.A, D2.C; no longer D15.A, D19.C
- net AC_N_LV_OUT: now also R13.1; no longer R12.1
- net AC_SENSE_PWR_EN: now also R33.2; no longer R32.2
- net BOOT0: now also R25.2; no longer R24.2
- net GND: now also D1.A, D2.A, R11.1, R20.2, R25.1, R27.2, R30.1, R32.2, R33.1, R39.1, R41.1, R42.2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; no longer D10.A, D19.A, R19.2, R24.1, R26.2, R28.1, R31.2, R32.1, R38.1, R40.1, R41.2, R44.2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
- net GPS_PWR_EN: now also R30.2; no longer R29.2
- net N$10: now also R26.2, R27.1; no longer R25.2, R26.1
- net N$17: now also D19.C, R36.2; no longer D27.C, R35.2
- net N$18: now also R18.2, R28.2; no longer R15.2, R27.2
- net N$23: now also R23.1, R37.1; no longer R22.1, R36.1
- net N$25: now also R31.2, R32.1; no longer R30.2, R31.1
- net N$3: now also R13.2, R41.2; no longer R12.2, R39.2
- net N$31: now also R37.2, R46.1, R47.2; no longer R36.2, R45.1, R46.2
- net N$32: now also D14.C; no longer D1.C
- net N$35: now also D12.C, D13.A; no longer D17.C, D18.A
- net N$37: now also D11.C, D12.A; no longer D16.C, D17.A
- net N$38: now also D10.C, D11.A; no longer D15.C, D16.A
- net N$4: now also R12.1, R39.2; no longer R11.1, R37.2
- net N$44: now also D17.C, R35.2; no longer D24.C, R34.2
- net N$46: now also D13.C; no longer D18.C
- net N$47: now also D15.C; no longer D21.C
- net N$5: now also R24.1; no longer R23.1
- net N$6: now also R43.1; no longer R41.1
- net N$8: now also R45.1; no longer R43.1
- net PARTICLE_RST: now also ASSY1.D3, R48.1; no longer R47.1
- net SD_ENABLE: now also R29.2; no longer R28.2
- net SD_MISO: now also R18.1; no longer R17.1
- net SD_MOSI: now also R16.1; no longer R15.1
- net SENSORS_SCL: now also R19.1; no longer R18.1
- net SENSORS_SDA: now also R15.1; no longer R14.1
- net SERIAL_NUM: now also R14.2; no longer R13.2
- net TDR_L_DETECT: now also R35.1; no longer R34.1
- net TDR_N_DETECT: now also R36.1; no longer R35.1
- net VCC: now also R14.1, R15.2, R19.2, R22.1, R34.1; no longer R13.1, R14.2, R18.2, R20.1, R33.1
- net WDI: now also R20.1; no longer R19.1
Other:
- moved on the sheet: D1, D10, D15, R12, R16, R17, R20, R21, R22, R23, R26, R27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

Commit message: remove previous production files and TDR circuit
Parts:
- removed C12, C13: 10nF, SparkFun-Capacitors:CAP1206
- removed C4, C5: 100pF, passives:CAPACITOR0402_CAP
- removed C6, C7: 1nF, passives:CAPACITOR0402_CAP
- removed D16, D17, D18, D19: 1000Vr, diode:DIODE-DO214AC
- removed D3, D4: 3V, SparkFun-DiscreteSemi:DIODE-ZENER-MM3Z3V3T1G
- removed R35, R36: 806k, passives:RESISTOR0805_RES
- removed R4, R5: 40.2, passives:RESISTOR0402_RES
- removed U15, U16, U17, U18: SN74LVC1G86DRLRDRL5-L, SN74LVC1G86:SN74LVC1G86DRLRDRL5-L
Connections:
- removed net !RST1: R4.2, U15.Y, U16.B
- removed net !RST2: R5.2, U17.Y, U18.B
- removed net A: C4.1, R4.1, U16.A
- removed net A2: C5.1, R5.1, U18.A
- removed net AC_N1: D16.A, U16.Y
- removed net AC_N2: D18.A, U18.Y
- removed net N$17: C13.1, D19.C, R36.2
- removed net N$44: C12.1, D17.C, R35.2
- removed net TDR_L_DETECT: ASSY1.B2, C6.1, D4.C, R35.1, U19.PA7
- removed net TDR_L_TRIGGER: ASSY1.B3, U15.B, U19.PA6
- removed net TDR_N_DETECT: ASSY1.B4, C7.1, D3.C, R36.1, U19.PA5
- removed net TDR_N_TRIGGER: ASSY1.B5, U17.B, U19.PA4
- net AC_L_HV_OUT: now also ASSY1.A0
- net AC_L_LV_OUT: now also ASSY1.B3; no longer ASSY1.A1
- net AC_L_SENSE: no longer D16.C, D17.A
- net AC_N: no longer D18.C, D19.A
- net AC_N_HV_OUT: now also ASSY1.B4
- net AC_N_LV_OUT: now also ASSY1.B5; no longer ASSY1.A0
- net AC_SENSE_VCC: no longer U15.VCC, U16.VCC, U17.VCC, U18.VCC
- net GND: no longer C12.2, C13.2, C4.2, C5.2, C6.2, C7.2, D3.A, D4.A, U15.A, U15.GND, U16.GND, U17.A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
Other:
- note removed: "The pulse response can up to double. We want to sense this impulse overlap (voltage increase) so we need a divider circuit. Zener protects the pin from overvoltage while AC is on. Capacitor allows for better ADC sampling due to high source impedance."
- note removed: "This circuit generates a pulse of ~4ns (modulo non-linear time delays). If the wire is shorter than a 4ns pulse time, the reflected voltage will be higher than the input voltage (3V3 - Vfr of the diode). If it's longer then it will not increase. 4ns should be 50-150cm depending on the wire and insulation."
- note removed: "This diode protects the output of the XOR. As low of drop as possible, very high Vr."
- note removed: "This is a sample and hold circuit. C needs to withstand AC voltages, D needs to have high Vr and low drop."

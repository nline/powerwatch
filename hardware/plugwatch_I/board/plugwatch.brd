# Repository nline/powerwatch

File README.md:

PowerWatch
==========

A custom PCB for identifying and distinguishing power outages. Acts as a source
of ground truth data for GridWatch.

Organized into different folders

./hardware - holds both board designs and case designs split by revision

./firmware - holds particle and nrf firmware split by revision. Firmware is built by travis.

./deployment-tools - holds all the software to support the deployment of physical devices and provision devices

## EAGLE design hardware/plugwatch_I/board/plugwatch.brd

File hardware/plugwatch_I/README.md:

# Plugwatch I

Plugwatch I has no functional changes and just changes the clearance between High voltage 
and low voltage copper on the board and fixes the hole size for soldered wires.

Parts:
C6, C7: 10nF; 0402_CAP; MPN GRM155R71C103KA01D; DIGIKEY 490-1313-1-ND
C10, C11, C12, C13: 0.1uF; 0402_CAP; MPN CC0402KRX5R6BB104; DIGIKEY 311-1336-1-ND
C27, C28: 100uF; 1210_CAP; MPN GRM32EC70J107ME15L; DIGIKEY 490-10530-1-ND
C29: 2000uF; E5-10,5; MPN EEU-FS0J202B; DIGIKEY P122284TB-ND
D1, D2: 3V; SOD-323; MPN MM3Z3V0ST1G; DIGIKEY MM3Z3V0ST1GOSCT-ND
D6, D7, D8, D9, D10, D11, D12, D13: 200V; DO214AA; MPN 1PGSMB5956 R5G; DIGIKEY 1PGSMB5956R5GCT-ND
D14, D15: 1000Vr; DO214AC; MPN S1M-13-F; DIGIKEY S1M-FDICT-ND
F1: 300VAC - 500ma; MIRCRO_FUSE_5MM
R1: 1; R2512; MPN CRM2512-JW-1R0ELF; DIGIKEY CRM2512-JW-1R0ELFCT-ND
R2, R3: 10; 0402_RES; MPN RC0402FR-0710RL; DIGIKEY 311-10.0LRCT-ND
R6, R7: 1.00k; 0402_RES; MPN RT0402BRE071KL; DIGIKEY YAG2306CT-ND
R10, R11: 3.74k; 0402_RES; MPN ERA-2AEB3741X; DIGIKEY P3.74KDCCT-ND
R31: 100k; 0402_RES; MPN RC0402FR-07100KL; DIGIKEY 311-100KLRCT-ND
R34, R35, R36, R37, R38, R39, R40, R41: 953k; 0805_RES; MPN ERA-6AEB9533V; DIGIKEY P953KDACT-ND
TP3, TP4: TEST_POINT_0.060IN; TESTPOINT_0.060IN
U2: ADA4096-4ACPZ-R7; CP_16_27; MPN ADA4096-4ACPZ-R7; DIGIKEY ADA4096-4ACPZ-R7CT-ND
U6: IRM-03-5V; IRM-03
U11: REF2030AIDDCR; DDC5; MANUFACTURER_PART_NUMBER REF2030AIDDCR; DIGIKEY 296-47351-1-ND
U14: SIP32510; TSOT23-6
V1: S14K385; MPN B72214S2381K101; DIGIKEY 495-5945-ND

Connections:
5V: C27.1, C28.1, C29.+, U6.V+; also elsewhere on the board
AC_L_800V_DETECT: C6.1, D1.C, D6.A; also elsewhere on the board
AC_L_HV_OUT: R6.2, U2.14 (OUT); also elsewhere on the board
AC_L_LV_OUT: R10.2, U2.7 (OUT); also elsewhere on the board
AC_L_SENSE: D14.A, F1.P$2, R1.1, R34.1, R39.2
AC_N: D15.A, R36.1, R40.2, TP4.TESTPOINT, U6.AC/N, V1.2
AC_N_800V_DETECT: C7.1, D2.C, D10.A; also elsewhere on the board
AC_N_HV_OUT: R7.2, U2.6 (OUT); also elsewhere on the board
AC_N_LV_OUT: R11.1, U2.15 (OUT); also elsewhere on the board
AC_SENSE_PWR_EN: R31.2, U14.3 (EN); also elsewhere on the board
AC_SENSE_VCC: U11.3 (EN), U11.4 (VIN), U14.1 (VLOAD), U14.2 (VLOAD); also elsewhere on the board
GND: C6.2, C7.2, C10.2, C11.2, C12.2, C13.2, C27.2, C28.2, C29.-, D1.A, D2.A, R31.1, R35.1, R37.1, R38.2, R41.2, U2.10 (V-), U2.17 (V-), U6.V-, U11.2 (GND), U14.4 (GND); also elsewhere on the board
unnamed: R1.2, U6.AC/L, V1.1
unnamed: R11.2, R36.2, R37.2, U2.1 (-)
unnamed: R10.1, R34.2, R35.2, U2.8 (-)
unnamed: R6.1, R38.1, R39.1, U2.12 (-)
unnamed: R7.1, R40.1, R41.1, U2.5 (-)
unnamed: F1.P$1, TP3.TESTPOINT
unnamed: D8.C, D9.A
unnamed: D7.C, D8.A
unnamed: D6.C, D7.A
unnamed: D9.C, R2.1
unnamed: D14.C, R2.2
unnamed: D12.C, D13.A
unnamed: D11.C, D12.A
unnamed: D10.C, D11.A
unnamed: D13.C, R3.1
unnamed: D15.C, R3.2
REF_1V5: C10.1, C11.1, C12.1, C13.1, U2.2 (+), U2.4 (+), U2.9 (+), U2.11 (+), U11.1 (VBIAS)
REF_3V: U2.3 (V+), U11.5 (VREF); also elsewhere on the board
VCC: U14.5 (VSUPP), U14.6 (VSUPP); also elsewhere on the board

Parts:
C1, C2: 4.3pF; 0402_CAP; MPN GJM1555C1H4R3CB01D; DIGIKEY 490-3099-1-ND
C14, C15, C16: 0.1uF; 0402_CAP; MPN CC0402KRX5R6BB104; DIGIKEY 311-1336-1-ND
C19, C20, C21: 1uF; 0402_CAP; MPN GCM155C71A105KE38D; DIGIKEY 490-13409-1-ND
C24: 4.7uF; 0402_CAP; MPN C1005X5R0J475K050BC; DIGIKEY 445-5947-1-ND
D5: LED0603; LED-0603; MPN SML-D12U1WT86; DIGIKEY SML-D12U1WT86CT-ND
J2: TC2030-JLINK-L; TC2030-IDC; MPN DNP; DIGIKEY DNP
R9: 1.69k; 0402_RES; MPN RC0402FR-071K69L; DIGIKEY YAG3044CT-ND
R23: 10k; 0402_RES; MPN RMCF0402FT10K0; DIGIKEY RMCF0402FT10K0CT-ND
S1: B3U-1000P
U15: STM32L432KC; UQFN-32
U16: TCA9406DCUR; DCU8; MPN TCA9406DCUR; DIGIKEY 296-28109-1-ND
U17: TPS79330DBVR; DBV5; MPN TPS79330DBVR; DIGIKEY 296-12159-1-ND
X1: ABS05-32.768KHZ-T; ABS05

Connections:
!RST: J2.3 (!RESET), S1.2, U15.4 (!RST)
AC_COPROC_VCC: C15.1, C16.1, C20.1, C21.1, C24.1, J2.1 (VCC), R9.2, U15.1 (VDD), U15.17 (VDD), U16.3 (VCCA), U16.6 (OE), U17.5 (OUT)
AC_L_800V_DETECT: U15.27 (PB4/!JTRST); also elsewhere on the board
AC_L_HV_OUT: U15.6 (PA0/CLKIN); also elsewhere on the board
AC_L_LV_OUT: U15.9 (PA3); also elsewhere on the board
AC_N_800V_DETECT: U15.28 (PB5); also elsewhere on the board
AC_N_HV_OUT: U15.10 (PA4); also elsewhere on the board
AC_N_LV_OUT: U15.7 (PA1); also elsewhere on the board
AC_SCL: U15.19 (PA9), U16.5 (SCL_A)
AC_SDA: U15.20 (PA10), U16.4 (SDA_A)
AC_SENSE_VCC: U17.1 (IN), U17.3 (EN); also elsewhere on the board
BOOT0: R23.2, U15.31 (PH3/BOOT0)
GND: C1.1, C2.1, C14.2, C15.2, C16.2, C19.2, C20.2, C21.2, C24.2, J2.5 (GND), R23.1, S1.1, U15.16 (VSS), U15.32 (VSS), U15.THERMAL (VSS), U16.2 (GND), U17.2 (GND); also elsewhere on the board
GPS_PPS: U15.26 (PB3/JTDO/SWO); also elsewhere on the board
unnamed: D5.A (ANODE), R9.1
unnamed: D5.C (CATHODE), U15.15 (PB1)
unnamed: C2.2, U15.3 (PC15/OSC32OUT), X1.A (1)
unnamed: C1.2, U15.2 (PC14/OSC32IN), X1.B (2)
REF_3V: C14.1, C19.1, U15.5 (VDDA/VREF); also elsewhere on the board
SENSORS_SCL: U16.8 (SCL_B); also elsewhere on the board
SENSORS_SDA: U16.1 (SDA_B); also elsewhere on the board
SWDCLK: J2.4 (SWDCLK), U15.24 (PA14/SWDCLK)
SWDIO: J2.2 (SWDIO), U15.23 (PA13/SWDIO)
VCC: U16.7 (VCCB); also elsewhere on the board
VOLTAGE_COPROC_RX: U15.30 (PB7); also elsewhere on the board
VOLTAGE_COPROC_TX: U15.29 (PB6); also elsewhere on the board

Parts:
B1: MS518SE; MS518SE-FL35E
C3: 47pF; 0402_CAP; MPN GRM1555C2A470JA01D; DIGIKEY 490-7307-1-ND
C17: 0.82uF; 0402_CAP; MPN CC0402KRX5R6BB824; DIGIKEY 311-3789-1-ND
C18: 1uF; 0402_CAP; MPN GCM155C71A105KE38D; DIGIKEY 490-13409-1-ND
C22: 2.2uF; 0402_CAP; MPN GRM155C70J225KE11D; DIGIKEY 490-12696-1-ND
JP1, JP2: M024UCON-15767; JST-2-SMD-VERT; MPN B2B-PH-SM4-TB(LF)(SN); DIGIKEY 455-1734-1-ND
Q1: MOSFET-NCHANNELSMD; SOT23-3; MPN 2N7002-7-F; DIGIKEY 2N7002-FDICT-ND
R18, R19, R20, R21, R22: 10k; 0402_RES; MPN RMCF0402FT10K0; DIGIKEY RMCF0402FT10K0CT-ND
R29, R30: 100k; 0402_RES; MPN RC0402FR-07100KL; DIGIKEY 311-100KLRCT-ND
R33: 825k; 0402_RES; MPN ERJ-2RKF8253X; DIGIKEY P825KLCT-ND
R42, R43, R44: 1M; 0402_RES; MPN RMCF0402FT1M00; DIGIKEY RMCF0402FT1M00CT-ND
U1: AB1815-T3; QFN-16-3MM
U9: MAX67XXMAX6749MAX67XX; SOT-23-8
X2: ABS07-32.768KHZ-7-T; 2-SMD

Connections:
5V: R29.1, R43.1; also elsewhere on the board
!EXTERNAL_RST: R21.2, U9.7 (!RESET); also elsewhere on the board
!RTC_CS: R20.2, R22.2, U1.12 (!CS); also elsewhere on the board
!RTC_INT1: R19.2, U1.11 (FOUT/!IRQ1); also elsewhere on the board
!RTC_INT2: U1.4 (!IRQ2); also elsewhere on the board
GND: B1.-, C3.2, C17.2, C18.2, C22.2, JP1.GND (1), JP2.GND (1), Q1.2 (S), R18.2, R30.2, R42.2, R44.2, U1.3 (!EXTR), U1.GND (VSS), U9.4 (GND); also elsewhere on the board
unnamed: B1.+, R22.1, U1.5 (VBAT)
unnamed: C3.1, U1.14 (AF)
unnamed: U1.15 (XO), X2.2
unnamed: U1.16 (XI), X2.1
unnamed: JP1.VCC (2), JP2.VCC (2), R21.1, R33.1, U9.5 (WDS), U9.8 (VCC)
unnamed: R29.2, R30.1, U1.10 (EXTI)
unnamed: Q1.3 (D), R33.2, R42.1, R43.2, U9.1 (!MR)
unnamed: C17.1, U9.3 (SRT)
unnamed: C22.1, U9.2 (SWT)
PARTICLE_RST: Q1.1 (G), R44.1; also elsewhere on the board
SD_MISO: U1.6 (SDO); also elsewhere on the board
SD_MOSI: U1.9 (SDI); also elsewhere on the board
SD_SCLK: U1.7 (SCL); also elsewhere on the board
VCC: C18.1, R19.1, R20.1, U1.13 (VCC); also elsewhere on the board
WDI: R18.1, U1.2 (WDI), U9.6 (WDI); also elsewhere on the board

Parts:
ASSY1: ELECTRON; ELECTRON_SINGLE-ROW; MPN PPPC181LFBN-RC; DIGIKEY S7051-ND,S7051-ND
C23: 4.7uF; 0402_CAP; MPN C1005X5R0J475K050BC; DIGIKEY 445-5947-1-ND
D29: SML-LX0404SIUPGUSB; 1MM_SQ_4PAD
J1: DM3AT-SF-PEJM5
Q2: NX3008PBK; SOT23-3
R4: 475; 0402_RES; MPN RMCF0402FT475R; DIGIKEY RMCF0402FT475RCT-ND
R5: 750; 0402_RES; MPN ERJ-2RKF7500X; DIGIKEY P750LCT-ND
R8: 1.69k; 0402_RES; MPN RC0402FR-071K69L; DIGIKEY YAG3044CT-ND
R12: 5.1k; 0402_RES; MPN ERJ-2RKF5101X; DIGIKEY P5.10KLCT-ND
R14, R15, R16: 10k; 0402_RES; MPN RMCF0402FT10K0; DIGIKEY RMCF0402FT10K0CT-ND
R24: 34k; 0402_RES; MPN ERJ-2RKF3402X; DIGIKEY P34.0KLCT-ND
R25: 66.5k; 0402_RES; MPN RC0402FR-0766K5L; DIGIKEY YAG3209CT-ND
R26, R27, R32: 100k; 0402_RES; MPN RC0402FR-07100KL; DIGIKEY 311-100KLRCT-ND
U4: DS2401P+; 21-0382
U10: MAX7315ATET; QFN50P300X300X80-17N; MPN MAX7315ATE+; DIGIKEY MAX7315ATE+-ND
U13: SIP32510; TSOT23-6

Connections:
5V: ASSY1.VIN, R24.1; also elsewhere on the board
!EXTERNAL_RST: ASSY1.RST; also elsewhere on the board
!RTC_CS: ASSY1.C5; also elsewhere on the board
!RTC_INT1: ASSY1.D5; also elsewhere on the board
!RTC_INT2: ASSY1.D3, Q2.1 (G), R32.2; also elsewhere on the board
!SD_CS: ASSY1.A2, J1.2 (DATA3-CD/CS_N), R15.1
!SD_DETECT: ASSY1.D6, J1.A, R26.1
ACCEL_INT: ASSY1.C4; also elsewhere on the board
AC_L_800V_DETECT: ASSY1.B1; also elsewhere on the board
AC_L_HV_OUT: ASSY1.A0; also elsewhere on the board
AC_L_LV_OUT: ASSY1.B3; also elsewhere on the board
AC_N_800V_DETECT: ASSY1.A1; also elsewhere on the board
AC_N_HV_OUT: ASSY1.B4; also elsewhere on the board
AC_N_LV_OUT: ASSY1.B5; also elsewhere on the board
AC_SENSE_PWR_EN: ASSY1.C3; also elsewhere on the board
DO_NOT_CONNECT: ASSY1.D7
GND: ASSY1.GND, ASSY1.GND@2 (GND), C23.2, J1.6 (GND), J1.B, J1.MOUNT0 (GND), J1.MOUNT1 (GND), J1.MOUNT2 (GND), J1.MOUNT3 (GND), R25.2, R27.1, U4.1 (GND), U10.6 (GND), U10.17 (EPAD), U13.4 (GND); also elsewhere on the board
GPS_PPS: ASSY1.D4; also elsewhere on the board
GPS_PWR_EN: ASSY1.B2; also elsewhere on the board
GPS_RXD: ASSY1.TX; also elsewhere on the board
GPS_TXD: ASSY1.RX; also elsewhere on the board
unnamed: ASSY1.WKP, Q2.3 (D), R24.2, R25.1
unnamed: C23.1, J1.4 (VCC), R14.2, R15.2, R16.2, R26.2, U13.1 (VLOAD), U13.2 (VLOAD)
unnamed: D29.3 (B), R4.1
unnamed: D29.4 (G), R5.1
unnamed: D29.2 (R), R8.1
unnamed: R8.2, U10.2 (P0)
unnamed: R5.2, U10.4 (P2)
unnamed: R4.2, U10.3 (P1)
PARTICLE_RST: ASSY1.D2; also elsewhere on the board
SD_ENABLE: ASSY1.C2, R27.2, U13.3 (EN)
SD_MISO: ASSY1.A4, J1.7 (DATA0/MISO), R16.1; also elsewhere on the board
SD_MOSI: ASSY1.A5, J1.3 (CMD/MOSI), R14.1; also elsewhere on the board
SD_SCLK: ASSY1.A3, J1.5 (CLK); also elsewhere on the board
SENSORS_SCL: ASSY1.D1, U10.12 (SCL); also elsewhere on the board
SENSORS_SDA: ASSY1.D0, U10.13 (SDA); also elsewhere on the board
SERIAL_NUM: ASSY1.B0, R12.2, U4.2 (DATA)
VCC: ASSY1.3V3, D29.1 (VDD), Q2.2 (S), R12.1, R32.1, U10.1 (AD2), U10.14 (V+), U10.15 (AD0), U10.16 (AD1), U13.5 (VSUPP), U13.6 (VSUPP); also elsewhere on the board
VOLTAGE_COPROC_RX: ASSY1.C1; also elsewhere on the board
VOLTAGE_COPROC_TX: ASSY1.C0; also elsewhere on the board
WDI: ASSY1.DAC; also elsewhere on the board

Parts:
A1: GPS-ANTENNA; ANT1818B00BT1516S; MPN ANT1818B00BT1516S; DIGIKEY 311-1531-ND
C4, C5: 10nF; 0402_CAP; MPN GRM155R71C103KA01D; DIGIKEY 490-1313-1-ND
C8: 0.1uF; 0402_CAP; MPN CC0402KRX5R6BB104; DIGIKEY 311-1336-1-ND
C26: 10uF; 0402_CAP; MPN GRJ155R60J106ME11D; DIGIKEY 490-13211-1-ND
L1: 5.6n; 0402_CAP; MPN LQW15AN5N6B80D; DIGIKEY 490-11766-1-ND
L2, L3: 1k; 0402_CAP; MPN BLM15HD102SN1D; DIGIKEY 490-4003-1-ND
R28: 100k; 0402_RES; MPN RC0402FR-07100KL; DIGIKEY 311-100KLRCT-ND
U3: BGA725L6-ALT; LNA-TSLP-6-2-ALT; MPN BGA725L6E6327FTSA1; DIGIKEY BGA725L6E6327FTSA1CT-ND
U5: SAFFB1G56KB0F0A; QCS5I; MPN F6QA1G575H2JF-J; DIGIKEY 587-5642-1-ND
U8: MAX-M8; MPN MAX-M8Q-0; DIGIKEY 672-1003-1-ND
U12: SIP32510; TSOT23-6

Connections:
ANT: A1.0 (1), L1.2
GND: A1.1 (2), A1.2, A1.3 (2), A1.4 (2), C4.1, C5.1, C8.1, C26.1, R28.1, U3.1 (GND), U3.4 (GND), U5.2 (GND), U5.3 (GND), U5.5 (GND), U8.1 (GND), U8.10 (GND), U8.12 (GND), U12.4 (GND); also elsewhere on the board
GPS_PPS: U8.4 (TIMEPULSE); also elsewhere on the board
GPS_PWR_EN: R28.2, U12.3 (EN); also elsewhere on the board
GPS_RF_IN: U5.4 (OUTPUT), U8.11 (RF_IN)
GPS_RXD: L3.2; also elsewhere on the board
GPS_TXD: L2.2; also elsewhere on the board
GPS_VCC: C5.2, C8.2, C26.2, U8.6 (V_BCKP), U8.7 (VCC_IO), U8.8 (VCC), U12.1 (VLOAD), U12.2 (VLOAD)
LNA_IN: L1.1, U3.5 (AI)
LNA_OUT: U3.3 (AO), U5.1 (INPUT)
unnamed: L2.1, U8.2 (TXD)
unnamed: L3.1, U8.3 (RXD)
VCC: U12.5 (VSUPP), U12.6 (VSUPP); also elsewhere on the board
VCC_RF: C4.2, U3.2 (VCC), U3.6 (PON), U8.14 (VCC_RF)

Notes on the sheet:
GPS
LNA
SAW

Parts:
C9: 0.1uF; 0402_CAP; MPN CC0402KRX5R6BB104; DIGIKEY 311-1336-1-ND
C25: 10uF; 0402_CAP; MPN GRJ155R60J106ME11D; DIGIKEY 490-13211-1-ND
R13, R17: 10k; 0402_RES; MPN RMCF0402FT10K0; DIGIKEY RMCF0402FT10K0CT-ND
U7: LIS2DH12; LGA-12; MPN LIS2DH12TR; DIGIKEY 497-14851-1-ND

Connections:
ACCEL_INT: U7.12 (INT1); also elsewhere on the board
GND: C9.2, C25.2, U7.3 (MISO/SA0), U7.5 (GND), U7.6 (GND), U7.7 (GND), U7.8 (GND); also elsewhere on the board
SENSORS_SCL: R17.1, U7.1 (SCL/SPC); also elsewhere on the board
SENSORS_SDA: R13.1, U7.4 (MOSI/SDA); also elsewhere on the board
VCC: C9.1, C25.1, R13.2, R17.2, U7.2 (CS), U7.9 (VCC), U7.10 (VDD_IO); also elsewhere on the board

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0

# Repository nline/powerwatch (continued)

## EAGLE design hardware/plugwatch_I/board/plugwatch.brd (continued)

Board: 4 copper layers, 55.7 x 95.2 mm, 123 parts (17 on the bottom side), 89 nets.

File hardware/plugwatch_I/board/plugwatch_bom.csv (part):

# Bill of Materials,,,,,,,,,,,
# Converted from {},,,,,,,,,,,
# Generated by bom_to_text.py,,,,,,,,,,,
#,,,,,,,,,,,
,,,,,,,,,,,
Qty,Value,Device,Package,Parts,Description,DESCRIPTION,DIGIKEY,MANUFACTURER,MOUSER,MPN,NEWARK
2,,M024UCON-15767,JST-2-SMD-VERT,"JP1,JP2",Header 2,CONN HEADER PH TOP 2POS 2MM SMD,455-1734-1-ND,JST Sales America Inc.,,B2B-PH-SM4-TB(LF)(SN),
1,,MS518SE,MS518SE-FL35E,B1,"A small, low leakage rechargeable battery for RTC backup",,728-1054-ND,Seiko,,MS518SE-FL35E,
1,,SML-LX0404SIUPGUSB,1MM_SQ_4PAD,D29,1mm^2 RGB LED,,67-2125-1-ND,Lumex Opto,,SML-LX0404SIUPGUSB,
9,0.1uF,CAPACITOR0402_CAP,0402_CAP,"C8,C9,C10,C11,C12,C13,C14,C15,C16",SMD Capacitor,CAP CER 0.1UF 10V X5R 0402,311-1336-1-ND,Yageo,,CC0402KRX5R6BB104,
1,0.82uF,CAPACITOR0402_CAP,0402_CAP,C17,SMD Capacitor,CAP CER 0.82UF 10V X5R 0402,311-3789-1-ND,Yageo,,CC0402KRX5R6BB824,
1,1,R-US_R2512,R2512,R1,"RESISTOR, American symbol",RES SMD 1 OHM 5% 2W 2512,CRM2512-JW-1R0ELFCT-ND,Bourns Inc.,,CRM2512-JW-1R0ELF,
2,1.00k,RESISTOR0402_RES,0402_RES,"R6,R7",Resistor,RES SMD 1K OHM 0.1% 1/16W 0402,YAG2306CT-ND,Yageo,,RT0402BRE071KL,
2,1.69k,RESISTOR0402_RES,0402_RES,"R8,R9",Resistor,RES SMD 1.69K OHM 1% 1/16W 0402,YAG3044CT-ND,Yageo,,RC0402FR-071K69L,
2,10,RESISTOR0402_RES,0402_RES,"R2,R3",Resistor,RES SMD 10 OHM 1% 1/16W 0402,311-10.0LRCT-ND,Yageo,,RC0402FR-0710RL,
2,1000Vr,DIODE-DO214AC,DO214AC,"D14,D15",DIODE,DIODE GEN PURP 1KV 1A SMA,S1M-FDICT-ND,Diodes Incorporated,,S1M-13-F,
7,100k,RESISTOR0402_RES,0402_RES,"R26,R27,R28,R29,R30,R31,R32",Resistor,RES SMD 100K OHM 1% 1/16W 0402,311-100KLRCT-ND,Yageo,,RC0402FR-07100KL,
2,100uF,CAPACITOR1210_CAP,1210_CAP,"C27,C28",SMD Capacitor,CAP CER 100UF 6.3V X7S 1210,490-10530-1-ND,Murata Electronics North America,,GRM32EC70J107ME15L,
1,10k,RESISTOR0402_RES,0402_RES,R23,Resistor,RES SMD 10K OHM 1% 1/16W 0402  ,RMCF0402FT10K0CT-ND  ,Stackpole Electronics Inc.  ,,RMCF0402FT10K0  ,
10,10k,RESISTOR0402_RES,0402_RES,"R13,R14,R15,R16,R17,R18,R19,R20,R21,R22",Resistor,RES SMD 10K OHM 1% 1/16W 0402 ,RMCF0402FT10K0CT-ND ,Stackpole Electronics Inc. ,,RMCF0402FT10K0 ,
4,10nF,CAPACITOR0402_CAP,0402_CAP,"C4,C5,C6,C7",SMD Capacitor,CAP CER 10000PF 16V X7R 0402,490-1313-1-ND,Murata Electronics North America,,GRM155R71C103KA01D,
2,10uF,CAPACITOR0402_CAP,0402_CAP,"C25,C26",SMD Capacitor,CAP CER 10UF 6.3V X5R 0402,490-13211-1-ND,Murata Electronics North America,,GRJ155R60J106ME11D,
3,1M,RESISTOR0402_RES,0402_RES,"R42,R43,R44",Resistor,RES 1M OHM 1% 1/16W 0402 ,RMCF0402FT1M00CT-ND ,Stackpole Electronics Inc ,,RMCF0402FT1M00 ,
2,1k,FERRITE_BEAD0402,0402_CAP,"L2,L3",,FERRITE BEAD 1 KOHM 0402 1LN,490-4003-1-ND,Murata,,BLM15HD102SN1D,
4,1uF,CAPACITOR0402_CAP,0402_CAP,"C18,C19,C20,C21",SMD Capacitor,CAP CER 1UF 10V X7S 0402,490-13409-1-ND,Murata Electronics North America,,GCM155C71A105KE38D,
1,2.2uF,CAPACITOR0402_CAP,0402_CAP,C22,SMD Capacitor,,490-12696-1-ND,Murata Electronics North America,,GRM155C70J225KE11D,
1,2000uF,CPOL-USE5-13,E5-13,C29,"POLARIZED CAPACITOR, American symbol",CAP ALUM 2000UF 20% 6.3V T/H,P122284TB-ND,Panasonic Electronic Components,,EEU-FS0J202B,
8,200V,DIODE-DO214AA,DO214AA,"D6,D7,D8,D9,D10,D11,D12,D13",DIODE,DIODE ZENER 200V 3W DO214AA,1PGSMB5956R5GCT-ND,Taiwan Semiconductor Corporation,,1PGSMB5956 R5G,
2,3.74k,RESISTOR0402_RES,0402_RES,"R10,R11",Resistor,RES SMD 3.74KOHM 0.1% 1/16W 0402,P3.74KDCCT-ND,Panasonic Electronic Components,,ERA-2AEB3741X,
1,300VAC - 500ma,MICRO_FUSE500MA_350VAC,MIRCRO_FUSE_5MM,F1,A 5mm AC micro fuse package,FUSE BRD MNT 500MA 350VAC 100VDC,507-1903-ND,Bel Fuse Inc,,0697H0500-01,
1,34k,RESISTOR0402_RES,0402_RES,R24,Resistor,RES SMD 34K OHM 1% 1/10W 0402,P34.0KLCT-ND,Panasonic Electronic Components,,ERJ-2RKF3402X,
2,3V,DIODE-ZENER-MM3Z3V3T1G,SOD-323,"D1,D2",Zener Diode,DIODE ZENER 3V 300MW SOD323,MM3Z3V0ST1GOSCT-ND,ON Semiconductor,,MM3Z3V0ST1G,
2,4.3pF,CAPACITOR0402_CAP,0402_CAP,"C1,C2",SMD Capacitor,CAP CER 4.3PF 50V C0G/NP0 0402,490-3099-1-ND,Murata Electronics North America,,GJM1555C1H4R3CB01D,
2,4.7uF,CAPACITOR0402_CAP,0402_CAP,"C23,C24",SMD Capacitor,CAP CER 4.7UF 6.3V X5R 0402 ,445-5947-1-ND ,TDK Corporation ,,C1005X5R0J475K050BC ,
1,475,RESISTOR0402_RES,0402_RES,R4,Resistor,RES 475 OHM 1% 1/16W 0402,RMCF0402FT475RCT-ND,Stackpole Electronics Inc,,RMCF0402FT475R,
1,47pF,CAPACITOR0402_CAP,0402_CAP,C3,SMD Capacitor,CAP CER 47PF 100V C0G/NP0 0402,490-7307-1-ND,Murata Electronics North America,,GRM1555C2A470JA01D,
1,5.1k,RESISTOR0402_RES,0402_RES,R12,Resistor,RES SMD 5.1K OHM 1% 1/10W 0402,P5.10KLCT-ND,Panasonic Electronic Components,,ERJ-2RKF5101X,
1,5.6n,INDUCTOR0402,0402_CAP,L1,A very specific inductor,FIXED IND 5.6NH 1.77A 40 MOHM,490-11766-1-ND,Murata,,LQW15AN5N6B80D,
1,66.5k,RESISTOR0402_RES,0402_RES,R25,Resistor,RES SMD 66.5K OHM 1% 1/16W 0402,YAG3209CT-ND,Yageo,,RC0402FR-0766K5L,
1,750,RESISTOR0402_RES,0402_RES,R5,Resistor,RES SMD 750 OHM 1% 1/10W 0402,P750LCT-ND,Panasonic Electronic Components,,ERJ-2RKF7500X,
1,825k,RESISTOR0402_RES,0402_RES,R33,Resistor,RES SMD 825K OHM 1% 1/10W 0402,P825KLCT-ND,Panasonic Electronic Components,,ERJ-2RKF8253X,
8,953k,RESISTOR0805_RES,0805_RES,"R34,R35,R36,R37,R38,R39,R40,R41",Resistor,RES SMD 953K OHM 0.1% 1/8W 0805,P953KDACT-ND,Panasonic Electronic Components,,ERA-6AEB9533V,
1,AB1815-T3,AB1815-T3,QFN-16-3MM,U1,Ultra-low current RTC. 55nA quiescent @ 3V. 1.5-3.6V input.,,535-11936-1-ND,Abracon,,AB1815-T3,
1,ABS05-32.768KHZ-T,ABS05-32.768KHZ-T,ABS05,X1,32.768kHz Crystal,,535-11899-1-ND,Abracon,,ABS05-32.768KHZ-T,
1,ABS07-32.768KHZ-7-T,ABS07-32.768KHZ-7-T,2-SMD,X2,32.768kHz Crystal,,535-9543-1-ND,ABRACON,,ABS07-32.768KHZ-7-T ,
1,ADA4096-4ACPZ-R7,ADA4096-4ACPZ-R7,CP_16_27,U2,,IC OPAMP GP 4 CIRCUIT 16LFCSP,ADA4096-4ACPZ-R7CT-ND,Analog Devices Inc.,,ADA4096-4ACPZ-R7,
1,B3U-1000P,B3U-1000P,B3U-1000P,S1,Switch,,SW1020CT-ND,Omron,,B3U-1000P,
1,BGA725L6-ALT,BGA725L6-ALT,LNA-TSLP-6-2-ALT,U3,,IC AMP MMIC RF LNA 20DB TSLP-6,BGA725L6E6327FTSA1CT-ND,Infineon,,BGA725L6E6327FTSA1,
1,DM3AT-SF-PEJM5,DM3AT-SF-PEJM5,DM3AT-SF-PEJM5,J1,CONN MICRO SD R/A PUSH-PUSH SMD,CONN MICRO SD CARD PUSH-PUSH R/A,HR1964CT-ND,Hirose Electric Co Ltd,,DM3AT-SF-PEJM5,
1,DS2401P+,DS2401P+,21-0382,U4,A one wire serial number chip.,,DS2401P+-ND,Maxim Integrated,,DS2401P+,
2,ELECTRON,ELECTRON,ELECTRON_SINGLE-ROW,ASSY1,,18 Position header,S7051-ND,Sullins,,PPPC181LFBN-RC,
1,GPS-ANTENNA,GPS-ANTENNA,ANT1818B00BT1516S,A1,,PATCH ANT GPS/GLO CP SMD,311-1531-ND,Yageo,,ANT1818B00BT1516S,
1,IRM-03-5V,IRM-03-5V,IRM-03,U6,A 5V 3W board mount power supply,,1866-3020-ND,Mean Well USA,,IRM-03-5,
1,LED0603,LED0603,LED-0603,D5,LED,LED RED DIFFUSED 1608 SMD,SML-D12U1WT86CT-ND,Rohm Semiconductor,,SML-D12U1WT86,
1,LIS2DH12,LIS2DW12,LGA-12,U7,ultra low power 3 axis accelerometer,,497-14851-1-ND,STMicroelectronics,511-LIS2DH12TR,LIS2DH12TR,
1,MAX-M8,MAX-M8,MAX-M8,U8,,IC RECEIVER GPS/GNSS 18LCC,672-1003-1-ND,u-blox,,MAX-M8Q-0,
1,MAX67XXMAX6749MAX67XX,MAX67XXMAX6749MAX67XX,SOT-23-8,U9,A simple watchdog timer with adjustable timeouts and reset time,,MAX6749KA+TCT-ND,Maxim Integrated,,MAX6749KA+T,
1,MAX7315ATET,MAX7315ATET,QFN50P300X300X80-17N,U10,,IC I/O EXPANDER I2C 8B 16TQFN,MAX7315ATE+-ND,Maxim Integrated,,MAX7315ATE+,
1,MOSFET-NCHANNELSMD,MOSFET-NCHANNELSMD,SOT23-3,Q1,Generic NMOS footprint,MOSFET N-CH 60V 115MA SOT23-3,2N7002-FDICT-ND,Diodes Incorporated,,2N7002-7-F,
1,NX3008PBK,NX3008PBK,SOT23-3,Q2,MOSFET - P Channel,,568-10499-1-ND,Nexperia,"771-NX3008PBK,215","NX3008PBK,215",74T4665
1,REF2030AIDDCR,REF2033AIDDCR,DDC5,U11,,IC VREF SERIES 1.5V/3V 5SOT,296-47351-1-ND,Texas Instruments,,REF2030AIDDCR,
1,S14K385,S14K385,S14K385,V1,VARISTOR,VARISTOR 620V 5KA DISC 14MM,495-5945-ND,EPCOS (TDK),,B72214S2381K101,
1,SAFFB1G56KB0F0A,FILTERS,QCS5I,U5,,FILTER SAW 1.575GHZ 5SMD,478-6835-1-ND,Kyocera International Inc. Electronic Components,,SF14-1575F5UUC1,
3,SIP32510,SIP32510,TSOT23-6,"U12,U13,U14","Load switch, slew rate controlled. By Vishay",, SIP32510DT-T1-GE3CT-ND,Vishay,,SIP32510DT-T1-GE3,
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
## Code that names these connections

File firmware/plugwatch_I/firmware/particle/src/board.h:

#define WDI DAC
#define SD_CS A3
#define AC_N_800V_DETECT A1
#define AC_L_800V_DETECT B1
#define SERIAL_NUM B0
#define GPS_PWR_EN B2
#define SD_ENABLE C2
#define AC_PWR_EN C3
#define ACCEL_INT C4
#define SD_DETECT D6
#define PARTICLE_RST D2
#define RTC_CS C5

## Commit log (part)

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2018-05-22 add flush on write...
2018-05-22 fix gps parsing
2018-05-22 add logging and unplug/plug fields
2018-05-22 add spark event stream logging
2018-05-25 removed SMS state
2018-05-26 support both nrf modes
2018-05-26 add supporting files for postgres poster
2018-05-26 making it compile
2018-05-27 change to PowerWatch_A product and Version 1
2018-05-27 adding in google sheets helper file and some small changes in timing for the claim script
2018-05-28 wit interigation and sticker script
2018-05-30 everything seems to be working except alter table portion
2018-05-30 added based 64 encoding of the wifi string
2018-05-31 abstract away packet parsing into generic module
2018-05-31 add var declaration, removed log statement
2018-05-31 add error handlers
2018-05-31 added upd listener
2018-05-31 add json interpretation
2018-05-31 added firmware with UDP packet sender
2018-06-01 add cellular timesync
2018-06-01 change to unix time
2018-06-01 condensing some of the data over the air
2018-06-01 indexed out of array
2018-06-01 added wit connection parser
2018-06-01 added catch on postgres listener
2018-06-01 fix ref error
2018-06-01 fix subscribe events
2018-06-02 change time source field to a tag
2018-06-02 add particle connection state control
2018-06-02 made a simple udp multiplexer
2018-06-02 added better error checking
2018-06-03 move the library out of the board-specific folder
2018-06-03 added power supervisory circuit
2018-06-04 adding in google sheets wrapper
2018-06-04 adding in preliminary firmware bin
2018-06-09 add commander options
2018-06-10 fixed parsing
2018-06-10 fix the parser
2018-06-14 add gsheets to postgres converter
2018-06-15 add some better survey checking
2018-06-15 fixed Wifi reporting with empty wifi lis t
2018-06-15 change gps time name
2018-06-15 add deploy firmware device filter
2018-06-19 changed to new survey format
2018-06-19 fix update carriers key error
2018-06-19 added base example without api key
2018-06-19 getting the data from the database!
2018-06-20 this kind of works but really takes too much memory
2018-06-20 a working visualization!
2018-06-25 fix utc offset problem
2018-06-26 add popup on click
2018-06-26 added favicon
2018-06-28 add a passport authentication service
    This should still be looked over before deployment, but I think
    I have sufficiently offloaded the authentication to google
2018-06-28 this is a better way to perform verification
2018-06-29 fix things for deployment
2018-06-29 add susanna
2018-06-29 add acl
2018-06-29 add new power supply with updated board shape
2018-07-03 rename to voltage
2018-07-04 added AC voltage sense and perturb/observe cap sensing
2018-07-04 add mic, remove many old things, connect RTC, new Accel
2018-07-04 switch the gnd float mosfet?
2018-07-04 a new mosfet configuration
2018-07-04 add inverter to watchdog reset line
2018-07-06 almost finished routing - still need to do debug signals
2018-07-06 layed out debug header, most of the way done routing
2018-07-06 fixed based on case, rerouted, some of the silk
2018-07-06 fixed some layout
2018-07-06 renumbered eagle parts
2018-07-07 fixed up BOM and attributes
2018-07-08 adding case files so I dont' lose them again
2018-07-08 move holes to match case
2018-07-10 add production files
2018-07-10 two testpoints were on the wrong side
2018-07-24 start new folder for rev 4 of the electron
2018-08-03 change SD enable pin
2018-08-03 add voltage sensing and capacitive pin sensing
2018-08-05 this isn't compiling yet, but it will soon
2018-08-06 this is working now without designated initializers
2018-08-06 added initial RTC implementation and integration
2018-09-15 commit rev 5 folder
2018-09-15 added the readme
2018-10-25 make it so that multiple product ideas listen in one process
2018-10-25 refactor organization of this repo - it was out of hand
2018-10-31 wifi working - that println wasn't necessary
2018-10-31 fix AB1815 library, update timesync to use it, can't power off SD while
    using RTC
2018-10-31 add WDI toggle to firmware
2018-11-01 add code that initializes the trickle charger
2018-11-01 fix RTC battery backup circuit, rename mislabeled SCL
2018-11-01 rename some of the components
2018-11-01 board order ready, BOM updated with purchasable parts
2018-11-01 add production of E
2018-11-02 make it so the firmware field doesn't have to present
2018-11-07 add a plugwatch_F version
2018-11-08 to assembly
2018-11-27 add plugwatch F firmware
2018-11-27 added a bunch of firmware readmes and describe ver
    new semantic versioning should work with particles decimal firmware
    revision number
2018-11-29 add the build settings file
2018-11-29 add build script and templating mechanism
2018-11-29 add a nigeria build settings
2018-11-30 fix firmware deployment script and version of build
2018-11-30 add nigeria apn and fix deploy firmware tool
2018-11-30 fix the version in some builds
2018-12-01 add more apns to predeploy firmware
2018-12-01 claim script getting updated - works better now
2018-12-01 claim script fully working, better bigger labels
2018-12-02 edited sticker
2018-12-03 add more requirements
2018-12-03 update readme, make folder if not exists
2018-12-12 add firmware analyzer
2019-01-03 add change that allows a re-lock of firmware
2019-01-03 fix frequency measurement
2019-01-09 add timeout to frequency check
2019-01-27 get predeploy firmware working like normal firmware
2019-01-27 declared var
2019-02-06 add predeploy for us testbed
2019-02-06 fix syntax error
2019-02-17 add plugwatch_F predeploy
    This stops the sensors from resetting on plug in
2019-02-17 bump version to include aeris APN
2019-02-18 final commit of the voltage averaging change
2019-03-19 add changes to claim script so that it inserts directly into postgres
    and properly updates already existing devices if desired
2019-03-29 add persistent SD card queueing for when cellular goes down
2019-03-30 fixed seek bug for get last line
2019-03-31 this is getting closer to sleeping. REally need to tear down cell state
2019-04-01 still need to try and disconnect
2019-04-02 add delay to catch power on
2019-04-03 add plugwatch G firmware for a future version with a Fixed R1
2019-04-28 fix readme
2019-04-28 update board and schematic with changes from last revision
2019-05-01 remove the submodules
2019-05-01 add apn and filtering to build script
2019-05-02 add label printing script
2019-05-02 fix the apn setting
2019-06-23 add new voltage amplifier circuit
2019-06-24 finish up direct voltage sensing, add coprocessor and i2c translator
2019-06-25 split the symbol up for the op amp so it's readable
2019-06-26 fix travis config
2019-06-26 another try on getting travis correct
2019-06-30 add LED with intensity driver to PW, start looking at layout
2019-07-02 add the start of an assembly manual
2019-07-02 add summary
2019-07-11 finish routing board
2019-07-11 renumber components, add cutout
2019-07-11 add board and schematic with final part numbers
2019-07-11 change name to plugwatch_bom
2019-09-19 remove previous production files and TDR circuit
2019-09-19 add a revision history of the board
2019-09-25 add a functional board description to ease with testing
2019-09-26 Add check boxes for functional verification
2019-09-27 fix travis for new structure
2019-09-28 add code into refactored library folder that can be linked and compiled
2019-09-28 add imu orientation to IMU result and accelerometer unit test
2019-09-28 add GPS test
2019-09-30 add reset test
2019-09-30 add new LED driver and unit test for driver
2019-09-30 add bug report
2019-09-30 confirm ID test working
2019-09-30 fix LED driver, run test
2019-10-01 fixed accel test, but tests is still failing - soldering issue?
2019-10-01 Add update on accel test
2019-10-01 update board testing log
2019-10-03 add rtc test
2019-10-03 add wakeup test to RTC test
2019-10-04 RTC interrupt tested and working
2019-10-04 add mbed support files
2019-10-04 add test code to blink the STM LED
2019-10-04 got I2C up and working between STM and particle
2019-10-04 add voltage test for STM
2019-10-05 fix reboot cnt increment
2019-10-05 add conducted watchdog tests
2019-10-31 add readme
2019-10-31 add particle voltage test
2019-11-01 add cellular quality test
2019-11-16 add changes
2019-11-20 update board to fix small issues. BOM should be the same
2019-12-09 add plugwatch H and some testing
2019-12-10 add a few changes
2019-12-10 verify more tests, add uart test
2019-12-23 add plugwatch revision I
2019-12-29 add plugwatch I firmware outline
2020-01-08 add single build script and identify firmware
2020-01-09 get general flow and entry/exit of sleep outlined
2020-01-09 get sleep outlined
2020-01-10 remove old subsystem superclass and refactor sub classes
2020-01-11 loop now running, physical RTC broken
2020-01-15 confirmed webhook sending and LED working
2020-01-16 try to fix up submodules
2020-01-16 move git module
2020-01-16 remove binaries from git
2020-02-07 add a version of the old firmware modified for plugwatch I
2020-02-07 add first pass at stm bootloader
2020-02-07 change connection timeouts to work with 2g
2020-02-07 extend state time to match other timers
2020-02-09 make data structure compatible, add send backoff and reset protocol
2020-02-10 change language back to node
2020-02-10 can't overwrite path
2020-02-10 fix variable substitution in travis file
2020-02-10 check secure key
2020-02-10 use travis to setup oauth
2020-02-11 try with pro option
2020-02-11 need to skip cleanup to deploy binary
2020-02-11 try to deploy both
2020-02-11 add it so that it builds the product
2020-02-11 remove built files - now using travis and github releases
2020-02-11 remove cellular only connection attempt
2020-02-11 fix semicolon
2020-02-11 working IMU angle and movement code
2020-02-11 fix voltage measurement
2020-02-11 try better frequency calculation
2020-02-12 lower LED brightness
2020-02-12 increase sampling frequency to try and reduce data costs
    This is counter intuitive, but should reduce the number of handshakes
2020-02-12 we aren't sleeping when we wake up without power
2020-02-14 add device claim code
2020-02-14 add more metrics to packet
2020-02-16 fixes watchdog send bug and strange cellular problem
    1) sendSuccess was not getting set on the webhook response, but on
    the particle publish success - no good. Watchdog wood not trigger if
    cloud comms failed
    2) Strange problem with particle cloud where if backoff time longer than
    aeris port close time (2 minutes) bad things happen. Rather than setting
    keepAlive, instead just don't let the backoff get over 2 minutes. Make
2020-02-16 fix test to catch a few smaller bugs like lack of power and only 1 packet causing errors
2020-03-04 add travis for new product
2020-03-11 fix up test file
2020-05-25 add testing instructions
2020-05-27 make the test script claim the device
2020-08-23 try to get travis auto deploying to particle for dev branches
2020-08-23 test another dev commit
2020-08-23 try single equal sign
2020-08-23 try to wrap in parens
2020-08-23 more parenthesis
2020-08-23 add print statement to debug deployment
2020-08-23 really needed to skip cleanup
2020-08-23 better stm product descriptions
2020-08-23 add python setuptools
2020-08-23 add quotes around url
2020-08-23 return errors better, add mbed dependencies
2020-08-24 try to fix the stm firmware release
2020-08-24 Try again to get stm releasing
2020-08-24 move file to output location
2020-08-24 fix caching issue
2021-01-12 setting up the i2s branch w example application
2021-02-04 add brew to readme
2021-02-09 add location flag
2021-03-05 make antenna error not crash
2021-03-05 catch i2c hang
